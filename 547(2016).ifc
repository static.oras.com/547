Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-09-06T12:46:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 06 12:46:35 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{59DEA75D-36A8-4BAC-B067-7C777C889E7B}\ifc * Database version: 5507 * Database creation date: Fri Sep 06 12:46:34 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 06 12:46:34 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 06 12:46:34 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 547 Shower set, 547(2016):547 Shower set:462238
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 129.7 mm; NominalHeight: 701 mm; NominalWidth: 98.9501 mm; Pipe Length: 650 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 547(2016); ConvergoRefNr: 0087-1909-0114-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 26/07/2019
Type - Green Building Properties(Type) - Customs Code: 39249000; EAN Number: 6414150077562; LVI Number: 6510171; NRF Number: 4204991; VVS Number: 737758444
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/547; Catalog Drawing URL: http://static.oras.com/catdrw/547; Dimension Drawing URL: http://static.oras.com/dimdrw/547; FDV Document URL: http://www.oras.com/datasheet/547/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/547; Group: Hand showers and shower sets; Long Marketing: Oras Apollo shower set including hand shower, 650 mm shower rail and a 1750 mm shower hose; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 547 Shower set; Name_en: 547 Shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 720 x 155 x 55; Package Weight: 1.033 kg; Product Code: 547; Product Datasheet: http://www.oras.com/datasheet/547/en; Product Family: Oras Apollo; Product Image URL: http://static.oras.com/image/547; Product URL: http://static.oras.com/547; Type Name: 547 Shower set
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Flow Rate At 300kPa: 0.0105944 m3/s; Hand Shower Size: Ø 95 mm; Installation and Maintenance: http://static.oras.com/manual/547; Installation Type: Wall-mounted; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Shower rail;Hand shower;Shower Hose (1750 mm)
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 547(2016); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 547; Name: 547 Shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 100x130x700 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 547; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 547 Shower set
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.173065 m2; Volume: 0.00899106 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 547(2016): 547 Shower set; Family and Type: 547(2016): 547 Shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 547(2016): 547 Shower set; Type Id: 547(2016): 547 Shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
